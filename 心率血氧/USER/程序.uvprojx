# Keil uVision project 程序.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 程序 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\ENCODER;..\HARDWARE\MOTOR;..\HARDWARE\TIMER;..\HARDWARE\CC2541;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\MAX30102;..\HARDWARE\KEY;..\HARDWARE\LCD1602;..\HARDWARE\DS18B20;..\HARDWARE\GPIO;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\source;..\USER;..\FreeRTOS\include;..\USER;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../FreeRTOS/include/: FreeRTOS.h FreeRTOSConfig.h task.h timers.h
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CC2541/: cc2541.c
    ../HARDWARE/MAX30102/: myiic.c algorithm.c max30102.c
    ../HARDWARE/LCD1602/: LCD1602.c
    ../HARDWARE/GPIO/: GPIO.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1_dma.c usart2_dma.c usart3_dma.c
    ../SYSTEM/delay/: delay.c delay.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_dbgmcu.c
  group FreeRTOS_COR
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
